# Keil uVision project PELab.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PELab
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=6 wLevel=3
  c define: CLOCK_SETUP=0
  c include: .\Source;.\Source\Application;.\Source\Profiler;.\Source\LCD;.\Source\ThreadVis
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Application
    ./Source/Application/: debug.c delay.c DMA.c I2C.c LEDs.c main.c MMA8451.c sound.c threads.c timers.c text_UI.c
  group LCD
    ./Source/LCD/: colors.c LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c lucida_20x31.c ST7789.c touchscreen.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
  group ThreadVis
    ./Source/ThreadVis/: new_events.c
  group Scripts
    ./Scripts/: find_sizes.bat update_regions_manually.bat update_regions_MDK.bat
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Compiler:Event Recorder 1.5.1, Device:Startup 2.5.0
