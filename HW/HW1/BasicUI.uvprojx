# Keil uVision project BasicUI.uvprojx, settings and files
target KL25Z Flash (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BasicUI
  c flags: Optim=2 v6Lang=5 v6LangP=5 wLevel=1
  c define: CLOCK_SETUP=1
  c include: include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group source
    ./src/: main.c LEDs.c delay.c UART.c timers.c DAC.c
  group include
    ./include/: gpio_defs.h delay.h LEDs.h timers.h UART.h DAC.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
