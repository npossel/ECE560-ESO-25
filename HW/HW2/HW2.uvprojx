# Keil uVision project HW2.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HW2
  AfterMake: Scripts\update_regions_MDK.cmd !L
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: CLOCK_SETUP=1
  c include: .\Include;.\Source;.\Source\Profiler;.\Source\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Source/: delay.c LEDs.c main.c MMA8451.c debug.c I2C.c timers.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
  group LCD
    ./Source/LCD/: LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c ST7789.c touchscreen.c colors.c
  group Scripts
    ./Scripts/: update_regions_MDK.bat find_sizes.bat
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
