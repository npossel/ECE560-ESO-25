# Keil uVision project Overlay.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Overlay
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=8 wLevel=3
  c include: Fonts;Profiling
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT5: ROM 0x8000 size 0x18000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c
  group Fonts
    ./Fonts/: font.h lucida_8x13.c lucida_12x19.c lucida_20x31.c
  group Profiler
    ./Profiler/: region.h regiontable.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
