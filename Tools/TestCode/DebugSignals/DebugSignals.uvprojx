# Keil uVision project DebugSignals.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DebugSignals
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c define: CLOCK_SETUP=1
  c misc: -ffp-mode=fast
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Source/: debug.c delay.c LEDs.c main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
