# Keil uVision project Histogrammer.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project_Base
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: DISABLE_WDOG=1, CLOCK_SETUP=1
  c misc: -Wunused-variable
  c include: ./Include;./Source;./Source/LCD;./Source/Profiler
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: debug.c delay.c LEDs.c main.c threads.c timers.c UI.c ADC.c hist.c
  group LCD
    ./Source/LCD/: LCD_graphics.c LCD_text.c lucida_8x13.c lucida_12x19.c lucida_20x31.c ST7789.c T6963.c touchscreen.c colors.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Device:Startup 2.5.0
