# Keil uVision project SpeedDemo-SG.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.12.0.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SpeedDemo-SG
  AfterMake: C:\Users\Alex\Documents\Teaching\ESO\ESO-2018\Code\ESO-18\Speed\SpeedDemo-SG\Scripts\update_regions_MDK.bat !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __stack_size__=2048
  c misc: --fpmode=fast
  c include: .\Include;.\Source\LCD;.\Source\Profiler
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source
    ./Source/: delay.c LEDs.c main.c geometry.c CMAN_coords2.c
  group Profiler
    ./Source/Profiler/: PIT.c profile.c region.c
software components: CMSIS:CORE 5.2.0, Device:Startup:MK64F12_startup 1.0.0
