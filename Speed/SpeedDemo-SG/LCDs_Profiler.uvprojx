# Keil uVision project LCDs_Profiler.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCDs_Profiler
  AfterMake: Scripts\update_regions_MDK.bat !L
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=3
  c define: CLOCK_SETUP=1
  c misc: -Wdouble-promotion -Wfloat-conversion
  c include: .\Include;.\Source;.\Source\Profiler;.\Source\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Source/: delay.c LEDs.c main.c debug.c timers.c CMAN_coords.c geometry.c queue.c UART.c
  group Profiler
    ./Source/Profiler/: profile.c region.c
  group LCD
    ./Source/LCD/: LCD_graphics.c LCD_text.c lucida_12x19.c ST7789.c touchscreen.c colors.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
